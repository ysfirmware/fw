# IAR project Cortex-M0.ewp, settings and files
configuration OK-STM32F0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ; Libraries\CMSIS\Include; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\STM32F0xx_StdPeriph_Driver\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OK-STM32F0.hex
  ILINK.IlinkOutputFile: OK-STM32F0.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group User
    ./: MPPT.c
