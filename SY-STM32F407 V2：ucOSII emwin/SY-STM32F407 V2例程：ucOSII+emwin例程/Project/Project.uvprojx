# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER DEBUG=1
  c include: ..\Libraries\CMSIS\inc;..\Libraries\FWlib\inc;..\Startup;..\User;..\Hardware\delay;..\Hardware\led;..\Hardware\usart;..\Hardware\lcd;..\GUIDemo;..\Config;..\GUI;..\ucos_ii\Source;..\ucos_ii\Ports;..\ucos_ii\GUI_X;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Hardware
    ../Hardware/delay/: delay.c
    ../Hardware/led/: led.c
    ../Hardware/usart/: usart.c
    ../Hardware/lcd/: glcd.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group CMSIS
    ../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group GUI
    ../GUI/: GUIv5_7m_tl___trial.lib LCD_X_8080_16.c
  group GUIDemo
    ../GUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Config
    ../Config/: GUIConf.c LCDConf.c
  group ucOS/Ports
    ../ucos_ii/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group ucOS/Source
    ../ucos_ii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucOS/GUI_X
    ../ucos_ii/GUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
  group BSP
    ../BSP/: bsp.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
