# IAR project STM32F746VET6.ewp, settings and files
configuration STM32F746VET6 Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746VE ST STM32F746VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F746VET6 Configuration.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
  group Drivers
    ./: 
  group Drivers/STM32F7xx_HAL_Driver
    ./: 
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal.c stm32f7xx_hal_dac.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_can.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_adc.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
