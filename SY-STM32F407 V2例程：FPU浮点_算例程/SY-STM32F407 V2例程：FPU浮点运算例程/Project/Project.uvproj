# Keil uVision project Project.uvproj, settings and files
target SY-STM32F407 V2.0 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c include: ..\Libraries\CMSIS\inc;..\Libraries\FWlib\inc;..\Startup;..\User;..\Hardware\delay;..\Hardware\led;..\Hardware\usart;..\Hardware\lcd;..\Dsp_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c arm_fft_bin_data.c
  group Hardware
    ../Hardware/delay/: delay.c
    ../Hardware/led/: led.c
    ../Hardware/usart/: usart.c
    ../Hardware/lcd/: lcd.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_rtc.c
  group CMSIS
    ../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group Dsp_Lib
    ../Dsp_Lib/: arm_cortexM4lf_math.lib
  group Doc
    ../: readme.txt
