# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\inc;..\Libraries\FWlib\inc;..\Startup;..\User;..\Hardware\delay;..\Hardware\led;..\Hardware\usart;..\Hardware\lcd;..\Hardware\touch;..\Hardware\adc;..\Hardware\spiflash;..\Hardware\rtc;..\Hardware\sdcard;..\Hardware\JPEG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Hardware
    ../Hardware/delay/: delay.c
    ../Hardware/led/: led.c
    ../Hardware/usart/: usart.c
    ../Hardware/lcd/: lcd.c
    ../Hardware/adc/: adc.c
    ../Hardware/spiflash/: spiflash.c
    ../Hardware/rtc/: rtc.c
    ../Hardware/sdcard/: sdcard.c
    ../Hardware/JPEG/: jpegdecode.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_sdio.c
  group CMSIS
    ../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
