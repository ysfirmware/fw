# IAR project Cortex-M7.ewp, settings and files
configuration OK-STM746 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746VG ST STM32F746VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: ; include; include\CMSIS; include\STM32F7xx_HAL_Driver\Inc; include\STM32F7xx_HAL_Driver\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OK-STM746.hex
  ILINK.IlinkOutputFile: OK-STM746.out
  ILINK.IlinkIcfFile: linker\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Include
    include/: startup_stm32f746xx.s
  group User
    ./: kit_test.c
