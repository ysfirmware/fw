# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xx; USE_STDPERIPH_DRIVER; TARGET_STM32F4XX=1; FEATURE_ASSERT_DBG=1
  ICCARM.CCIncludePath2: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\drv
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM.hex
  ILINK.IlinkOutputFile: EWARM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group drv
    ../drv/: assert.c led.c startup_stm32f40xx.s system_stm32f4xx.c
  group lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group src
    ./: main.c
